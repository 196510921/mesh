# Keil uVision project juma_ble.uvprojx, settings and files
target JUMA_BLE (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: mesh +hex
  c flags: Optim=4 uC99=1
  c define: NRF51 BOARD_PCA10001 SETUPA DEBUG_NRF_USER
  c misc: --c99
  c include: ..\..\..\Include;..\..\btle_hci\advertiser\Include;..\..\btle_hci\fifo\Include;..\..\..\Include\app_common;..\..\..\Include\ble\ble_services;..\..\..\Include\ble;..\..\..\Include\s110;..\..\observer\Include;..\..\mesh_app\Include
  memory RVCT4: ROM 0x16000 size 0x26000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group app
    ../: main.c
  group lib
    ../../../Source/simple_uart/: simple_uart.c
  group btle_hci
    ../../btle_hci/advertiser/: ts_peripheral.c
  group user
    ../../mesh_app/Source/: router.c mesh_baseband.c mesh_app.c
    ../../baseband/Source/: fsm_adv_generic.c fsm_sconn.c
    ../../host/: att.c slave_dispatch.c
  group ::Device
    RTE/Device/nRF51822_xxAA/: arm_startup_nrf51.s system_nrf51.c
target MESH (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: mesh +hex
  c flags: Optim=4 uC99=1
  c define: NRF51 BOARD_PCA10001 SETUPA DEBUG_NRF_USER
  c misc: --c99
  c include: ..\..\..\Include;..\..\btle_hci\advertiser\Include;..\..\btle_hci\fifo\Include;..\..\..\Include\app_common;..\..\..\Include\ble\ble_services;..\..\..\Include\ble;..\..\..\Include\s110;..\..\observer\Include;..\..\mesh_app\Include;..\..\host\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
